** Profile: "SCHEMATIC1-Ac_sweep"  [ D:\p1\p1_2023_munteanu_lorena-PSpiceFiles\SCHEMATIC1\Ac_sweep.sim ]

** Creating circuit file "Ac_sweep.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/mmbfj309lt1g.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/mmbfj177lt1g.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/mjd32cg.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/mjd31cg.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/irfr120npbf.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c10.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c8v2.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c6v8.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c6v2.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c5v6.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c5v1.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bzx84c2v7.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bc856b.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bc846b.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bc817-25.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/bc807-25.lib"
.LIB "c:/cadence/spb_17.2/tools/capture/library/modele_a1_lib/1n4148.lib"
.LIB "c:/users/munte/desktop/pp1/modele-spice-led-uri_2022/opto/opto.lib"
.LIB "c:/users/munte/desktop/pp1/modele-spice-led-uri_2022/smlk18wbjxw/smlk18wbjxw/smlk18wbjxw.lib"
.LIB "c:/users/munte/desktop/pp1/modele-spice-led-uri_2022/smls14bet/smls14bet/smls14bet.lib"
* From [PSPICE NETLIST] section of C:\Users\munte\AppData\Roaming\SPB_Data\cdssetup\OrCAD_PSpice\17.2.0\PSpice.ini file:
.lib "nomd.lib"

*Analysis directives:
.AC DEC 1000 0.1 100Meg
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
